<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MOTENV1_IKS01A3_WB55RG_OTA.ewp</path>
  </project>
  <batchBuild />
</workspace>
