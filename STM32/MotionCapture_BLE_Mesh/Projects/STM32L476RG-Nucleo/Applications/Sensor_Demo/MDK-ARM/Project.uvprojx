# Keil uVision project Project.uvprojx, settings and files
target Sensor-STM32_BNRGMS (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Project +hex
  AfterMake: fromelf --bincombined Sensor-STM32_BNRGMS\Exe\Project.axf -o Sensor-STM32_BNRGMS\Exe\Project.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L4,STM32L476xx,STM32L476xG,STM32,USE_STM32L4XX_STEVAL_IDB00xV1,USE_HAL_DRIVER,USER_DEFINED_PLATFORM,STM32L4XX_MD,SYSCLK_FREQ_HSI_32MHz,BLUENRG_CONFIG=BLUENRG_32_MHZ_RO,BLUENRG_MS,USE_STM32L4XX_NUCLEO,ENABLE_USART,NUCLEO_L476RG,DISABLE_TRACES,STM32_BLUENRGMS
  c include: ../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/BSP/STM32L4xx_Nucleo;..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB05A1;../../../../../Drivers/BSP/Components/lsm6dso/;../../../../../Drivers/BSP/Components/lis2dw12/;../../../../../Drivers/BSP/Components/lis2mdl/;../../../../../Drivers/BSP/Components/hts221/;../../../../../Drivers/BSP/Components/lps22hh/;../../../../../Drivers/BSP/Components/stts751/;../../../../../Drivers/BSP/IKS01A3/;../../../../../Drivers/BSP/Components/Common/;../../../../../Middlewares/ST/STM32_BlueNRG/STM32L4xx_HAL_BlueNRG_Drivers/inc;../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/includes;../../../../../Middlewares/ST/ST_BLE_Mesh/Inc;../../../../../Middlewares/ST/ST_BLE_Mesh/Porting/config;../../../../../Middlewares/ST/ST_BLE_Mesh/MeshModel/Inc;../../../../../Middlewares/ST/STM32_BlueNRG/Interface;../../../../../Projects/STM32L476RG-Nucleo/Applications/Sensor_Demo/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\Nucleo-L476RG.sct
  link misc: --diag_suppress=L6329
--no_strict_wchar_size
--diag_suppress=L6436W
--diag_suppress=L6775W
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
    ./: data_l4.s
  group Application/User
    ../Src/: appli_generic.c appli_light.c appli_light_lc.c appli_mesh.c appli_nvm.c appli_sensor.c appli_vendor.c cube_hal_l4.c main.c mesh_cfg.c models_if.c stm32l4_nucleo_l476rg.c stm32l4xx_hal_msp.c stm32l4xx_hal_nvm.c stm32l4xx_it.c stm32l4xx_nucleo_bus.c user_if.c appli_config.c appli_config_client.c appli_generic_client.c appli_light_client.c appli_sensors_client.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/IKS01A3
    ../../../../../Drivers/BSP/IKS01A3/: iks01a3_env_sensors.c iks01a3_env_sensors_ex.c iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c
  group Drivers/BSP/STM32L4xx-Nucleo
    ../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-BNRG2A1
    ../../../../../Drivers/BSP/X-NUCLEO-BNRG2A1/: stm32_bluenrg_ble.c
  group Drivers/BSP/X-NUCLEO-IDB05A1
    ../../../../../Drivers/BSP/X-NUCLEO-IDB05A1/: stm32_bluenrg_ble.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c
  group Middlewares/ST_BLE_MESH/MeshModel
    ../../../../../Middlewares/ST/ST_BLE_Mesh/MeshModel/Src/: common.c generic.c light.c light_lc.c sensors.c time_scene.c vendor.c config_client.c generic_client.c light_client.c sensors_client.c
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c hci_le.c
  group Middlewares/STM32_BlueNRG/HCI/Controller
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_IFR.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils.c
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf.c
  group Middlewares/STM32_BlueNRG/STM32L4xx_HAL_BlueNRG_Drivers
    ../../../../../Middlewares/ST/STM32_BlueNRG/STM32L4xx_HAL_BlueNRG_Drivers/src/: stm32l4xx_hal_bluenrg_spi.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: ble_list.c gp_timer.c osal.c
  group Middlewares/STM32_BlueNRG1/Utils
    ../../../../../Middlewares/ST/STM32_BlueNRG1/HAL/src/: clock.c gp_timer.c list.c osal.c
  group Middlewares/STM32_BlueNRG1/HCI
    ../../../../../Middlewares/ST/STM32_BlueNRG1/SimpleBlueNRG1_HCI/hci/: bluenrg1_events.c bluenrg1_hci_le.c hci.c
  group Middlewares/STM32_BlueNRG1/HCI/Controller
    ../../../../../Middlewares/ST/STM32_BlueNRG1/SimpleBlueNRG1_HCI/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/STM32_BlueNRG1/STM32L4xx_HAL_BlueNRG1_Drivers
    ../../../../../Middlewares/ST/STM32_BlueNRG1/STM32L4xx_HAL_BlueNRG1_Drivers/src/: stm32l4xx_hal_bluenrg1_spi.c
  group Middlewares/ST/ST_BLE_Mesh/Lib
    ../../../../../Middlewares/ST/ST_BLE_Mesh/Lib/: libBlueNRG_Mesh_CM4-BNRGMS_wc32_ot.a
    ../../../../../Middlewares/ST/ST_BLE_MESH/Lib/: libBlueNRG_Mesh_CM4-BNRG2A1_wc32_ot.a
  group Middlewares/ST/ST_Cryptolib/STM32L4/Lib
    ../../../../../Middlewares/ST/ST_Cryptolib/STM32L4/Lib/: STM32CryptographicV3.1.1_CM4_IARv8_otnsc.a
target Sensor-STM32_BNRG2A1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: as above
  output: Project +hex
  AfterMake: fromelf --bincombined Sensor-STM32_BNRG2A1\Exe\Project.axf -o Sensor-STM32_BNRG2A1\Exe\Project.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L4,STM32L476xx,STM32L476xG,STM32,USE_STM32L4XX_STEVAL_IDB00xV1,USE_HAL_DRIVER,USER_DEFINED_PLATFORM,STM32L4XX_MD,SYSCLK_FREQ_HSI_32MHz,BLUENRG_CONFIG=BLUENRG_32_MHZ_RO,BLUENRG_MS,USE_STM32L4XX_NUCLEO,ENABLE_USART,NUCLEO_L476RG,DISABLE_TRACES,SPI_INTERFACE,STM32_BLUENRG1,BLUENRG1_NWK_COPROC,DISABLE_TRACES
  c misc: --C99
  c include: ../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/BSP/STM32L4xx_Nucleo;../../../../../Drivers/BSP/X-NUCLEO-BNRG2A1;../../../../../Drivers/BSP/Components/lsm6dso/;../../../../../Drivers/BSP/Components/lis2dw12/;../../../../../Drivers/BSP/Components/lis2mdl/;../../../../../Drivers/BSP/Components/hts221/;../../../../../Drivers/BSP/Components/lps22hh/;../../../../../Drivers/BSP/Components/stts751/;../../../../../Drivers/BSP/IKS01A3/;../../../../../Drivers/BSP/Components/Common/;../../../../../Middlewares/ST/STM32_BlueNRG1/STM32L4xx_HAL_BlueNRG1_Drivers/inc;../../../../../Middlewares/ST/STM32_BlueNRG1/SimpleBlueNRG1_HCI/includes;../../../../../Middlewares/ST/ST_BLE_Mesh/Inc;../../../../../Middlewares/ST/ST_BLE_Mesh/Porting/config;../../../../../Middlewares/ST/ST_BLE_Mesh/MeshModel/Inc;../../../../../Middlewares/ST/STM32_BlueNRG/Interface;../../../../../Middlewares/ST/STM32_BlueNRG1/HAL/inc;../../../../../Projects/STM32L476RG-Nucleo/Applications/Sensor_Demo/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\Nucleo-L476RG.sct
  link misc: --diag_suppress=L6329
--no_strict_wchar_size
--diag_suppress=L6436W
software components: CMSIS:CORE 5.2.0
