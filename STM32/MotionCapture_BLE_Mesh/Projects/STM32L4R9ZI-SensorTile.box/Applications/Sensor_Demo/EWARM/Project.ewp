# IAR project Project.ewp, settings and files
configuration Sensor-STBOX (ARM)
  General.OGChipSelectEditMenu: STM32L4R9ZI ST STM32L4R9ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4R9xx; STM32; USE_STM32L4XX_STEVAL_IDB00xV1; USE_HAL_DRIVER; USER_DEFINED_PLATFORM; USE_STM32_SENSORTILEBOX; DISABLE_TRACES; SPI_INTERFACE; _BLUENRG_MS; BLUENRG1_DEVICE; BLUENRG1_NWK_COPROC; TRACE_ENABLE_NO_FUNCTION; STM32_SENSORTILEBOX; STM32_BLUENRG1; FSM_FF_ENABLE=0; MLC_6D_ENABLE=0; MLC_FANMON_ENABLE=0; STBOX1_ENABLE_PRINTF
  ICCARM.CCIncludePath2: ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\Drivers\BSP\Components\lis2mdl; ..\..\..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\..\..\Drivers\BSP\Components\stts751; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsox; ..\..\..\..\..\Drivers\BSP\SensorTile.box; ..\..\..\..\..\Middlewares\ST\STM32_BlueNRG1\STM32L4xx_HAL_BlueNRG1_Drivers\inc; ..\..\..\..\..\Middlewares\ST\STM32_BlueNRG1\SimpleBlueNRG1_HCI\includes; ..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\Inc; ..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\Porting\config; ..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\MeshModel\Inc; ..\..\..\..\..\Middlewares\ST\STM32_BlueNRG1\HAL\inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Sensor-STBOX.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkKeepSymbols: __nvmbase_data
  ILINK.IlinkIcfFile: stm32l4r9xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\Lib\libBlueNRG_Mesh_CM4-STBOX_wc32_ot.a; ..\..\..\..\..\Middlewares\ST\ST_Cryptolib\STM32L4\Lib\STM32CryptographicV3.1.1_CM4_IARv8_otnsc.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l4r9xx.s
  group Application/User
    ../Src/: appli_config.c appli_config_client.c appli_generic.c appli_generic_client.c appli_light.c appli_light_client.c appli_light_lc.c appli_mesh.c appli_nvm.c appli_sensor.c appli_sensors_client.c appli_vendor.c cube_hal_l4.c main.c mesh_cfg.c models_if.c stm32_bluenrg_ble.c stm32l4xx_hal_msp.c stm32l4xx_hal_nvm.c stm32xx_it.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c user_if.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox/: lsm6dsox.c lsm6dsox_reg.c
    ../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/SensorTile.box
    ../../../../../Drivers/BSP/SensorTile.box/: SensorTile.box.c SensorTile.box_bc.c SensorTile.box_bus.c SensorTile.box_env_sensors.c SensorTile.box_motion_sensors.c
    ../Src/: TargetPlatform.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_ll_usb.c
  group Middlewares/ST_BLE_MESH/MeshModel
    ../../../../../Middlewares/ST/ST_BLE_MESH/MeshModel/Src/: common.c config_client.c generic.c generic_client.c light.c light_client.c light_lc.c sensors.c sensors_client.c time_scene.c vendor.c
  group Middlewares/STM32_BlueNRG1/HCI
    ../../../../../Middlewares/ST/STM32_BlueNRG1/SimpleBlueNRG1_HCI/hci/: bluenrg1_events.c bluenrg1_hci_le.c hci.c
  group Middlewares/STM32_BlueNRG1/HCI/Controller
    ../../../../../Middlewares/ST/STM32_BlueNRG1/SimpleBlueNRG1_HCI/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/STM32_BlueNRG1/STM32L4xx_HAL_BlueNRG1_Drivers
    ../../../../../Middlewares/ST/STM32_BlueNRG1/STM32L4xx_HAL_BlueNRG1_Drivers/src/: stm32l4xx_hal_bluenrg1_spi.c
  group Middlewares/STM32_BlueNRG1/Utils
    ../../../../../Middlewares/ST/STM32_BlueNRG1/HAL/src/: clock.c gp_timer.c list.c low_power.c osal.c
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
